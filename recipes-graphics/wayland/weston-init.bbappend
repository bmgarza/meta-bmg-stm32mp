<<<<<<< Updated upstream
SRC_URI:append:stm32mp-qemuarm64 = " file://ST30739_background-1920x1080.png "
=======
SRC_URI:append:qemuarm64 = " file://ST30739_background-1920x1080.png "
SRC_URI:append:stm32mp-qemuarm64 = " file://ST30739_background-1920x1080.png "
DEFAULT_WESTON_BACKGROUND:qemuarm64 = "ST30739_background-1920x1080.png"
>>>>>>> Stashed changes
DEFAULT_WESTON_BACKGROUND:stm32mp-qemuarm64 = "ST30739_background-1920x1080.png"
