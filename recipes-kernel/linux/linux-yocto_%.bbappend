COMPATIBLE_MACHINE:stm32mp-qemuarm64 = "(stm32mp-qemuarm64)"
